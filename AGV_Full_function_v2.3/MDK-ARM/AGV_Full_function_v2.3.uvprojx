# Keil uVision project AGV_Full_function_v2.3.uvprojx, settings and files
target AGV_Full_function_v2.3 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: AGV_Full_function_v2.3
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: gpio.c tim.c usart.c main.c spi.c stm32f4xx_it.c stm32f4xx_hal_msp.c adc.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc_ex.c
software components: CMSIS:CORE 4.1.0
